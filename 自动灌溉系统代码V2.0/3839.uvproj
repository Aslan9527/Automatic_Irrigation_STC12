# Keil uVision project 3839.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 3839 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Header
  group Sources
    ./: STARTUP.A51
  group User
    ./User/: main.c
